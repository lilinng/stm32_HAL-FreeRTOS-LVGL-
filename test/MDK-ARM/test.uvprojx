# Keil uVision project test.uvprojx, settings and files
target test (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MiddleWare/FreeRTOS/Inc;../MiddleWare/LVGL/GUI;../MiddleWare/LVGL/GUI/lvgl;../MiddleWare/LVGL/GUI/lvgl/src;../MiddleWare/LVGL/GUI/lvgl/example/porting
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../MiddleWare/FreeRTOS/Inc/: FreeRTOSConfig.h
    ../Core/Src/: main.c gpio.c fsmc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Src
    ../MiddleWare/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../MiddleWare/FreeRTOS/Portable/: heap_4.c port.c
  group LVGL/Src
    ../MiddleWare/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../MiddleWare/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
    ../MiddleWare/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../MiddleWare/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../MiddleWare/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../MiddleWare/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../MiddleWare/LVGL/GUI/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../MiddleWare/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../MiddleWare/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../MiddleWare/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/Porting
    ../MiddleWare/LVGL/GUI/lvgl/example/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
software components: CMSIS:CORE 4.3.0
